# Keil uVision project EgFWD_Car_Door_Control_ECU2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EgFWD_Car_Door_Control_ECU2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\TivaWare
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./App/: main.c
  group MCAL
    C:/TivaWare/driverlib/rvmdk/: driverlib.lib
  group OnBoard
    ./OnBoard/: buzzer.c buzzer.h left_light.c left_light.h right_light.c right_light.h
  group Library
    ./Library/: common_macros.h Std_Types.h
software components: CMSIS Driver:CAN:Custom 1.0.0, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
